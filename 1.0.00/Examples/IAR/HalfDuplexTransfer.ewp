# IAR project HalfDuplexTransfer.ewp, settings and files
configuration GATEWAY_A110LR09BP430G2x53 (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430fn.h
  General.OGChipSelectMenu: MSP430G2553 MSP430G2553
  General.GStackSize2: 90
  General.GHeapSize2: 0
  General.RadioHeapSizeType: 0
  ICC430.PreInclude: ..\Source\HalfDuplexTransfer\Gateway\HalfDuplexTransferLR09Config.h
  ICC430.newCCIncludePaths: ..\..\Source\API; ..\..\Source\DataLink\MAC; ..\..\Source\DataLink\PhyBridge; ..\..\Source\Physical\A110x2500\Driver; ..\..\Source\Physical\A110x2500\Module; ..\..\Source\Physical\A110x2500\Module\A110LR09; ..\..\Source\Physical\A110x2500\PhyBridge
  ICC430.CCOptLevel: 0
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430G2553.xcl
  XLINK.XlinkStackSize: 1
configuration ENDPOINT_A110LR09BP430G2x53 (MSP430, debug)
  as the first configuration, except:
  ICC430.PreInclude: ..\Source\HalfDuplexTransfer\EndPoint\HalfDuplexTransferLR09Config.h
  group Application/EndPoint
    ../Source/HalfDuplexTransfer/EndPoint/: HalfDuplexTransfer.c
  group Application/Gateway
    ../Source/HalfDuplexTransfer/Gateway/: HalfDuplexTransfer.c
  group Application/Platform
    ../Source/_Platforms/MSP430/: BPEXP430G2x53.c
  group Protocol/API
    ../../Source/API/: API.c
    ../../code/API/: API.h
  group Protocol/DataLink/MAC
    ../../Source/DataLink/MAC/: Frame.c PhyAddress.c
    ../../code/DataLink/MAC/: Frame.h PhyAddress.h
  group Protocol/DataLink/PhyBridge
    ../../code/DataLink/PhyBridge/: PhyBridge.h
  group Protocol/Physical/Driver
    ../../Source/Physical/A110x2500/Driver/: CC1101.c
    ../../code/Physical/A110x2500/Driver/: CC1101.h
  group Protocol/Physical/Module
    ../../code/Physical/A110x2500/Module/: A110x2500.h
  group Protocol/Physical/Module/A110LR09
    ../../Source/Physical/A110x2500/Module/A110LR09/: A110LR09.c
    ../../code/Physical/A110x2500/Module/A110LR09/: A110LR09.h A110LR09Config.h
  group Protocol/Physical/PhyBridge
    ../../Source/Physical/A110x2500/PhyBridge/: A110x2500PhyBridge.c
    ../../code/Physical/A110x2500/PhyBridge/: A110x2500PhyBridge.h
